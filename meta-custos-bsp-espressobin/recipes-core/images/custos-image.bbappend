# Custos layout on the ESPRESSObin microSD: boot, root and a /data partition
# for persistent service state (files/wic/custos-espressobin.wks in this layer).
WKS_FILE:espressobin = "custos-espressobin-ab.wks"

# Armada 3720 PCIe: load the Wi-Fi driver only when the card answers
# (recipes-bsp/custos-pcie-guard).
IMAGE_INSTALL:append:espressobin = " custos-pcie-guard"

# A13 A/B updates: RAUC glue, kernel and DTB inside the root file system
# (boot.scr loads them from /boot of the selected slot), and an ext4 image
# of the root file system for the update bundle (custos-bundle).
IMAGE_INSTALL:append:espressobin = " custos-rauc kernel-image kernel-devicetree"
IMAGE_FSTYPES:append:espressobin = " ext4"
# meta-rauc's rauc-mark-good would mark every boot good; Custos marks a slot
# good only after its health check (custos-health.timer).
BAD_RECOMMENDATIONS:append = " rauc-mark-good"

# U-Boot loads /boot/Image and /boot/<dtb> by these exact names (no
# version suffix, no vendor subdirectory, no symlink).
ROOTFS_POSTPROCESS_COMMAND:append:espressobin = " custos_boot_files;"
custos_boot_files() {
    b=${IMAGE_ROOTFS}/boot
    img=$(ls $b/${KERNEL_IMAGETYPE}-* 2>/dev/null | head -n 1)
    [ -n "$img" ] || bbfatal "no kernel image in /boot"
    rm -f $b/${KERNEL_IMAGETYPE}
    cp $img $b/${KERNEL_IMAGETYPE}
    dtb=$(find $b -name "${ESPRESSOBIN_DTB}" | head -n 1)
    [ -n "$dtb" ] || bbfatal "no ${ESPRESSOBIN_DTB} in /boot"
    [ "$dtb" = "$b/${ESPRESSOBIN_DTB}" ] || cp $dtb $b/${ESPRESSOBIN_DTB}
}

# A10: read-only root file system. Persistent state is on /data (services,
# SSH host key, timesyncd clock: volatile-binds_%.bbappend), the rest of
# /var is volatile. boot.scr passes "ro".
IMAGE_FEATURES:append:espressobin = " read-only-rootfs"

# A10: dm-verity hash tree appended to the ext4 image (same partition,
# hash area after the file system). The ext4 file system is unchanged: it
# ends where its superblock says, so U-Boot and a plain mount still work.
# The root hash goes into the update bundle (custos-verity.env) and from
# there, through the RAUC post-install hook, into custos-boot.env for the
# slot. custos-verity-check compares the slot against it at boot; booting
# from the dm-verity device itself is the next step (docs/boot-chain.md).
CUSTOS_VERITY_BLOCK = "4096"
# No ext4 journal: the root file system is never written, and on the first
# mount (even read-only) the kernel rewrites the journal superblock, which
# changes the slot against its root hash (block 65536 = journal inode 8,
# "Verification failed at position 268435456", 2026-11-21).
EXTRA_IMAGECMD:ext4:append:espressobin = " -O ^has_journal"
do_image_ext4[depends] += "cryptsetup-native:do_populate_sysroot"
# A postfunc, not an IMAGE_CMD:ext4 append: the append is joined into the
# mkfs.ext4 command line ("invalid inode ratio 4096n", 2026-11-21).
do_image_ext4[postfuncs] += "custos_verity_hash"
custos_verity_hash() {
    img=${IMGDEPLOYDIR}/${IMAGE_NAME}.ext4
    bs=${CUSTOS_VERITY_BLOCK}
    size=$(stat -c %s $img)
    size=$(expr \( $size + $bs - 1 \) / $bs \* $bs)
    truncate -s $size $img
    out=$(veritysetup format --data-block-size=$bs --hash-block-size=$bs \
        --hash-offset=$size $img $img)
    echo "$out"
    env=${IMGDEPLOYDIR}/${IMAGE_NAME}.verity.env
    {
        echo "VERITY_DATA_BLOCKS=$(echo "$out" | sed -n 's/^Data blocks:[[:space:]]*//p')"
        echo "VERITY_HASH_OFFSET=$size"
        echo "VERITY_ROOT_HASH=$(echo "$out" | sed -n 's/^Root hash:[[:space:]]*//p')"
        echo "VERITY_SALT=$(echo "$out" | sed -n 's/^Salt:[[:space:]]*//p')"
    } > $env
    grep -qE '^VERITY_ROOT_HASH=[0-9a-f]{64}$' $env || bbfatal "veritysetup gave no root hash"
    [ "$(sed -n 's/^VERITY_DATA_BLOCKS=//p' $env)" = "$(expr $size / $bs)" ] || bbfatal "verity data blocks != image size"
    ln -sf ${IMAGE_NAME}.verity.env ${IMGDEPLOYDIR}/${IMAGE_LINK_NAME}.verity.env
}

# Read-only /etc: audit-rules.service runs "augenrules --load", which writes
# /etc/audit/audit.rules when it differs from rules.d. Generate it here with
# augenrules' own merge rules, so on the board it compares equal and is only
# loaded.
ROOTFS_POSTPROCESS_COMMAND:append:espressobin = " custos_audit_rules;"
custos_audit_rules() {
    d=${IMAGE_ROOTFS}${sysconfdir}/audit
    [ -d $d/rules.d ] || return 0
    {
        echo "## This file is automatically generated from /etc/audit/rules.d"
        for r in $(ls -1v $d/rules.d | grep '\.rules$'); do cat $d/rules.d/$r; done | awk '
        BEGIN { e = ""; D = ""; f = ""; b = ""; n = 0 }
        {
            sub(/\r$/, "")
            if (length($0) < 1) next
            if (match($0, "^[[:space:]]*#")) next
            if (match($0, "^[[:space:]]*-e")) { e = $0; next }
            if (match($0, "^[[:space:]]*-D[[:space:]]*$")) { D = $0; next }
            if (match($0, "^[[:space:]]*-f")) { f = $0; next }
            if (match($0, "^[[:space:]]*-b")) { b = $0; next }
            r[n++] = $0
        }
        END { printf "%s\n%s\n%s\n", D, b, f; for (i = 0; i < n; i++) printf "%s\n", r[i]; printf "%s\n", e }'
    } > $d/audit.rules
    chmod 0640 $d/audit.rules
}
