custos-image.bbappend